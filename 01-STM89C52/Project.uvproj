# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: SizeSpeed=1
  c include: ..\01-STM89C52
  group Source Group 1
    ./: STARTUP.A51 lesson2_LED.c main.c
